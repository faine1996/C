<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Task2_DHT_EventFlags.ewp</path>
  </project>
  <batchBuild />
</workspace>
